# Keil uVision project Sensor.uvprojx, settings and files
target Sensor (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Sensor +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L431xx
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\..\APP;..\..\Bsp;..\..\Common;..\..\Common\ringbuffer;..\..\Driver;..\..\Device;..\..\Common\data_protocol;..\..\OperatingSystem\TencentOS-tiny\arch\common;..\..\OperatingSystem\TencentOS-tiny\arch\cortex-m4\armcc;..\..\OperatingSystem\TencentOS-tiny\arch\common\include;..\..\OperatingSystem\TencentOS-tiny\kernel\core\include;..\..\OperatingSystem\TencentOS-tiny\kernel\hal;..\..\OperatingSystem\TencentOS-tiny\osal;..\..\OperatingSystem\TencentOS-tiny\platform;..\..\OperatingSystem\TencentOS-tiny
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c i2c.c spi.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group App
    ../../APP/: App.c
  group Bsp
    ../../Bsp/: Lcd.c AMG883x.c
  group Common
    ../../Common/ringbuffer/: ring_buffer.c
    ../../Common/: Until.c
  group Driver
    ../../Driver/: i2c_driver.c
  group Device
    ../../Device/: i2c_device_amg8833.c
  group Platfrom
    ../../OperatingSystem/TencentOS-tiny/arch/common/: tos_cpu.c
    ../../OperatingSystem/TencentOS-tiny/arch/cortex-m4/armcc/: port_c.c port_s.S
    ../../OperatingSystem/TencentOS-tiny/platform/: tos_hal_uart.c
    ../../OperatingSystem/TencentOS-tiny/kernel/core/: tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_rwlock.c tos_sched.c tos_sem.c tos_stopwatch.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
    ../../OperatingSystem/TencentOS-tiny/: tos_config.h
    ../../OperatingSystem/TencentOS-tiny/osal/: cmsis_os.c
software components: CMSIS:CORE 4.3.0
